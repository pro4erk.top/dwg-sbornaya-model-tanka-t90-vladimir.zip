# KOMPAS-3D part (ú¿α«ß¬«» ñáΓτ¿¬.m3d)

Model tree:
1. Эскиз:1
2. Операция выдавливания:1
     Расстояние 1 = 18
3. Скругление:1
     Радиус = 1
