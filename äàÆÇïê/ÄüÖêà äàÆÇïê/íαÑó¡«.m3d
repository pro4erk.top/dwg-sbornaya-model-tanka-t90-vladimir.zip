# KOMPAS-3D part (íαÑó¡«.m3d)

Model tree:
1. Эскиз:1
2. Операция выдавливания:1
     Расстояние 1 = 102; Расстояние 2 = 102

Texts:
  Пиломатериал береза  ГОСТ 2695-83