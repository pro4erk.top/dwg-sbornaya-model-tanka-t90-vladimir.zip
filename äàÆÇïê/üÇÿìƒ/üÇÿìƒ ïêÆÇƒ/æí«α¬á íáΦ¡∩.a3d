# KOMPAS-3D assembly (æí«α¬á íáΦ¡∩.a3d)

Referenced files in D:\МОДЕЛЬ ТАНКА Т90\ДЕТАЛИ\БАШНЯ\БАШНЯ ЛИТАЯ\: Сборка башня низ.a3d, Сборка башня с навесками.a3d
Texts:
  stalker61