# KOMPAS-3D assembly (æí«α¬á ΦΓ«αá.a3d)

Referenced files in D:\МОДЕЛЬ ТАНКА Т90\ДЕТАЛИ\БАШНЯ\башня сварная\: крепления шторы.m3d, штора.m3d
Texts:
  stalker61