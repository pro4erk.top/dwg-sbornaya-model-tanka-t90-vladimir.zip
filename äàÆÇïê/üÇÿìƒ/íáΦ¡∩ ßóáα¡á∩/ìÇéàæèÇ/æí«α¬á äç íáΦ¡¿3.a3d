# KOMPAS-3D assembly (æí«α¬á äç íáΦ¡¿3.a3d)

Referenced files in D:\МОДЕЛЬ ТАНКА Т90\ДЕТАЛИ\БАШНЯ\башня сварная\НАВЕСКА\: ДЗ башни.m3d
Texts:
  Сборка ДЗ башни3