# KOMPAS-3D assembly (æí«α¬á ¬«α¼á óÑασ.a3d)

Referenced files in D:\МОДЕЛЬ ТАНКА Т90\ДЕТАЛИ\КОРПУС\МЕТАЛЛ\КОРПУС ЛИТОЙ\: корма верх 1.m3d
Texts:
  Сборка корма верх
  stalker61