# KOMPAS-3D assembly (æí«α¬á ¬«α¼á.a3d)

Referenced files in D:\МОДЕЛЬ ТАНКА Т90\ДЕТАЛИ\КОРПУС\МЕТАЛЛ\КОРПУС ШТАМПОВКА\: корма.m3d
Texts:
  stalker61